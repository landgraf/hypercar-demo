PACKAGECONFIG:append = " zstd "