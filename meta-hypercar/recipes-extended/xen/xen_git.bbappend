SRCREV = "608f85a1818697156b72ace4913a17c8178a0ef5"
XEN_BRANCH = "master"

SRC_URI:remove = " file://xen-flask-race-fix.patch"