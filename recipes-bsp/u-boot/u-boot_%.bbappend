DEPENDS:append = " qemu-dtb-native"
