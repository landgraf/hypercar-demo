SRCREV = "91d4d9506a4e8906253d1280bd5a1f39668fad64"
XEN_BRANCH = "staging"

SRC_URI:remove = " file://xen-flask-race-fix.patch"